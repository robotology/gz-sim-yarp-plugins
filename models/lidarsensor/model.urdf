Commit message: fixed lidarsensor model

File: models/lidarsensor/model.urdf (robot description, URDF)
Before this commit: robot lidarsensor_model, 1 links, 0 joints
Links:
- link dummy_link1: mass None -> 1; geometry visual mesh filename=package://lidarsensor/lasermesh.stl scale=0.001 0.001 0.001
